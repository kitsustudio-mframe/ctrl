# Keil uVision project ctrl.uvprojx, settings and files
target cm0 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ctrl_cm0 (library)
  AfterMake: cmd.exe /C copy .keil\cm0\Objects\ctrl_cm0.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src/virt
    ./virt/: AnalogInputPin.cpp AnalogInputPin.h GeneralPin.cpp GeneralPin.h package-info.h TemperatureSensor.cpp TemperatureSensor.h
  group src
    ./: Ammeter.cpp Ammeter.h package-info.h SerialPort.cpp SerialPort.h SerialPortInputStream.cpp SerialPortInputStream.h SerialPortOutputStream.cpp SerialPortOutputStream.h TemperatureSensor.h Voltmeter.cpp Voltmeter.h
target cm3 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ctrl_cm3 (library)
  AfterMake: cmd.exe /C copy .keil\cm3\Objects\ctrl_cm3.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cm4f (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ctrl_cm4f (library)
  AfterMake: cmd.exe /C copy .keil\cm4f\Objects\ctrl_cm4f.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
